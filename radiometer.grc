<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>radiometer</value></param>
<param><key>author</key><value>Marcus Leech, CCERA</value></param>
<param><key>description</key><value>A FFT-based radiometer/spectrometer</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>FFT Radiometer</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cimag</value></param>
<param><key>value</key><value>list(numpy.imag(probe_cpx))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>creal</value></param>
<param><key>value</key><value>list(numpy.real(probe_cpx))</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fcn_corr_probe</value></param>
<param><key>block_id</key><value>scalar_corr_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fcn_tp_probe1</value></param>
<param><key>block_id</key><value>scalar_tp_probe1</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fcn_tp_probe2</value></param>
<param><key>block_id</key><value>scalar_tp_probe2</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>comment</key><value>Probably best to just leave this as-is.

For much-wider bandwidth, upping to
  4096 or 8192 could be considered, but for
  our target Odroid platform, that may be a
  non-starter.</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frate</value></param>
<param><key>value</key><value>(int(samp_rate/fftsize))/sratio</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fwidth</value></param>
<param><key>value</key><value>radiometer_helper.fringe_rate(declination,freq,baseline)*1.10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>int_alpha</value></param>
<param><key>value</key><value>radiometer_helper.derive_alpha(samp_rate,2.5)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>log_status</value></param>
<param><key>value</key><value>radiometer_helper.log([probe_result,probe_result1,creal,cimag],longitude,latitude,lstore,rstore,expname,freq,samp_rate,alpha,declination,speclog,excl,fast,[fcn_corr_probe,fcn_tp_probe1,fcn_tp_probe2],console)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>probe_cpx</value></param>
<param><key>block_id</key><value>fft_corr_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[complex(0.0,0.0)]*fftsize</value></param>
<param><key>poll_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>probe_result</value></param>
<param><key>block_id</key><value>fft_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[0.1]*fftsize</value></param>
<param><key>poll_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>probe_result1</value></param>
<param><key>block_id</key><value>fft_probe1</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[0.1]*fftsize</value></param>
<param><key>poll_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(srate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sratio</value></param>
<param><key>value</key><value>1.65 if fast == 0 else 15.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>abw</value></param>
<param><key>label</key><value>Analog Bandwidth</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>5.0e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha</value></param>
<param><key>label</key><value>Alpha value for TP integrator</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>antenna</value></param>
<param><key>label</key><value>Antenna Selector</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>baseline</value></param>
<param><key>label</key><value>Baseline Length(m)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>5.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bbgain</value></param>
<param><key>label</key><value>Baseband gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_1</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_1_0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>m</key><value>int(fftsize)</value></param>
<param><key>n</key><value>int(fftsize*sratio)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0</value></param>
<param><key>m</key><value>int(fftsize)</value></param>
<param><key>n</key><value>int(fftsize*sratio)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>int(frate*2.5)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>n</key><value>int(frate*2.5)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0_0</value></param>
<param><key>n</key><value>int(frate*2.5)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1</value></param>
<param><key>n</key><value>1 if fast == 1 else 100</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1_0</value></param>
<param><key>n</key><value>1 if fast == 1 else 100</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1_0_0</value></param>
<param><key>n</key><value>1 if fast == 1 else 100</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1_1</value></param>
<param><key>n</key><value>1 if fast == 1 else 100</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_2</value></param>
<param><key>n</key><value>samp_rate/2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_2_0</value></param>
<param><key>n</key><value>samp_rate/2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_2_0_0</value></param>
<param><key>n</key><value>samp_rate/2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>[hp]*fftsize</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>hp</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>complex(math.cos(math.radians(phase)), math.sin(math.radians(phase)))</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>clock</value></param>
<param><key>label</key><value>Clock Source</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>internal</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>console</value></param>
<param><key>label</key><value>Console data logging</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>declination</value></param>
<param><key>label</key><value>Decliantion</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>41</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device</value></param>
<param><key>label</key><value>Device string</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>airspy=0,pack=1 file=/dev/zero,rate=10.0e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>excl</value></param>
<param><key>label</key><value>Frequency exclusions</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>expname</value></param>
<param><key>label</key><value>Experiment Name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"TESTING"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fast</value></param>
<param><key>label</key><value>Fast correlator mode</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>fft_corr_probe</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>fft_probe</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>fft_probe1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>comment</key><value>Performance improved slightly by not doing
the shift operation here.</value></param>
<param><key>fft_size</key><value>fftsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value>window.blackmanharris(fftsize)</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>fft_size</key><value>fftsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value>window.blackmanharris(fftsize)</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>foo</value></param>
<param><key>alpha</key><value>int_alpha</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1420.4058e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hp</value></param>
<param><key>label</key><value>High Pass Enable</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ifgain</value></param>
<param><key>label</key><value>IF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>latitude</value></param>
<param><key>label</key><value>Local Latitude</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>44.9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>longitude</value></param>
<param><key>label</key><value>Local Longitude</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-76.03</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lstore</value></param>
<param><key>label</key><value>Local Storage Location</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"/mnt/data/astro_data"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>What happens here is that once per second,
  radiometer_helper.log() is called with a bunch
  of parameters, including the FFT vectors.

Said vectors have already been integrated
fairly heavily, and contains the FFT
magnitude data in *linear* form.

The conversion to 10*log10() form is done
   inside the logging function.

The logging function also computes the total
  power across the bandwidth, from linear-form
  FFT magnitudes.

Log files are created, as well as .JSON snapshot
  files.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>comment</key><value>******* Command-line parameters here  ****</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>comment</key><value>This FG ALWAYS runs as a DIFFERENTIAL 
radiometer.  In the case of a single receiver
we use the /dev/zero file as a source of 
virtual zero-valued samples.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3</value></param>
<param><key>note</key><value>Cheap DC Block</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_4</value></param>
<param><key>comment</key><value>A simple single-lag correlator across the two FFT
outputs.  Fed to a DC-block.

This is further processed in the logger, providing
  further integration, and total-power calculations
  across all the FFT bins.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_5</value></param>
<param><key>comment</key><value>So-called "fast" mode.

We effectively shut-down the FFTs, by reducing
  the data-flow to a trickle.  Then enable a
sub-graph that computes just the scalars.</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>ant0</key><value>antenna</value></param>
<param><key>bb_gain0</key><value>bbgain</value></param>
<param><key>bw0</key><value>abw</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>ifgain</value></param>
<param><key>gain0</key><value>rfgain</value></param>
<param><key>ant1</key><value>antenna</value></param>
<param><key>bb_gain1</key><value>bbgain</value></param>
<param><key>bw1</key><value>abw</value></param>
<param><key>dc_offset_mode1</key><value>2</value></param>
<param><key>corr1</key><value>0</value></param>
<param><key>freq1</key><value>freq</value></param>
<param><key>gain_mode1</key><value>False</value></param>
<param><key>if_gain1</key><value>ifgain</value></param>
<param><key>iq_balance_mode1</key><value>0</value></param>
<param><key>gain1</key><value>rfgain</value></param>
<param><key>args</key><value>device</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>phase</value></param>
<param><key>label</key><value>East/West phase correcion, degrees</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppstime</value></param>
<param><key>label</key><value>PPS Time Input</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>internal</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>radiometer_helper</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph
import os
import ephem
import json
import math
import numpy
import time
import sys

then = time.time()

#
# Given a frequency and width, compute the
#  bins in a given FFT size to exclude from
#  calculations.
#
# On input, must know:
#   FFT length
#   Fc
#   Total bandwidth represented by FFT
#   The centroid of the exclusion frequency
#   The width of the exclusion zone
#
def derive_exclusion(fftl,freq,bw,efreq,ewid):
    binw = bw/fftl
    startf = freq-(bw/2.0)
    offset = efreq - startf
    offset -= (ewid/2.0)
    end = offset + ewid
    
    offset /= binw
    offset = int(offset)
    
    end /= binw
    end = int(end)
    
    #
    # Handle effective zero-width case
    #  (due to integer round-down)
    #
    if (end == offset):
        end = offset+1

    #
    # Handle offsets spilling off the end
    #
    if (offset &lt; 0):
        offset = 0
    if (offset &gt;= fftl):
        offset = fftl-1
    
    
    if (end &lt; 0):
        end = 0
    if (end &gt;= fftl):
        end = fftl-1

    #
    # Handle effective zero-width case
    #  (due to integer round-down)
    #
    if (end == offset):
        end = offset+1
        
    return [offset,end]
    
    

#
# sum an fft-like, with a list of exclusion zones
#
def fftsum(vec,exlist):
    
    #
    # First derive the total sum
    #
    sum1 = numpy.sum(vec)
    
    #
    # Then subtract-out
    #  The zones of exclusion
    #
    for ex in exlist:
        st = ex[0]
        en = ex[1]
        sum1 -= numpy.sum(vec[st:en])
        
    return sum1

#
# Get current sidereal time
#
# Only required input for our purposes is longitude
#
def cur_sidereal(longitude):
    longstr = "%02d" % int(longitude)
    longstr = longstr + ":"
    longitude = abs(longitude)
    frac = longitude - int(longitude)
    frac *= 60
    mins = int(frac)
    longstr += "%02d" % mins
    longstr += ":00"
    x = ephem.Observer()
    x.date = ephem.now()
    x.long = longstr
    jdate = ephem.julian_date(x)
    tokens=str(x.sidereal_time()).split(":")
    hours=int(tokens[0])
    minutes=int(tokens[1])
    seconds=int(float(tokens[2]))
    sidt = "%02d,%02d,%02d" % (hours, minutes, seconds)
    return (sidt)
    
count = 0
curr_diff = -99.00
curr_sky = -99.00
curr_ref = -99.00
curr_corr_real = -99.00
curr_corr_imag = -99.00


def log(ffts,longitude,latitude,local,remote,expname,freq,bw,alpha,declination,speclog,excl,fast,scalars,console):
    global then
    #
    # Protect against getting called too often
    #
    if ((time.time() - then) &lt; 1.0):
        return False
    else:
        then = time.time()
    
    #
    # So that on most calls, we end up doing nearly-nothing before returning
    #
    global count
    global curr_diff
    global curr_sky
    global curr_ref
    global curr_corr_real
    global curr_corr_imag
    SKY = 0
    REF = 1
    CORR_REAL = 2
    CORR_IMAG = 3
    
    #
    # In fast mode, the scalars are not derived from the FFT bits and pieces
    # The FFT outputs are only used as coarse estimates of spectrum
    #
    # There are a separate set of (fast-mode-only) scalars passed to us
    #   instead
    #
    if (fast == 0):
        #
        # For exclusions in vector sum (notching-out offensive regions)
        #   most notably the DC-offset region, where there can often be
        #   large spikes
        #
        # But also any user-supplied regions 
        #
        exclusions=[]
        
        #
        # It is most convenient for the user to specify exclusions in terms
        #   of frequency and width, so we have a derivation function that
        #   turns that into a tuple-like of [start,end]
        #
        exclusions.append(derive_exclusion(len(ffts[0]),freq,bw,freq,25.0e3))
    
        #
        # Process user-provided exclusion(s)
        #
        if (excl != "" and excl != "none"):
            for v in excl.split(","):
                t = v.split(":")
                e = derive_exclusion(len(ffts[0]),freq,bw,float(t[0]),float(t[1]))
                exclusions.append(e)
    
    beta = 1.0-alpha
    
    sums = []
    sffts = []
    for fft in ffts:
        
        #first shift the fft output
        lfft = len(fft)
        newfft = fft[lfft/2:lfft]
        newfft += fft[0:lfft/2]
        
        #
        # Scale by FFT size
        #
        newfft = numpy.divide (newfft, [lfft]*lfft)
        sffts.append(newfft)
    
    #
    # Handle differencing of the two FFT arrays
    #
    if (len(ffts) == 1):
        sfft = sffts[SKY]
    else:
        sfft = numpy.subtract(sffts[SKY], sffts[REF])
        sfft = numpy.absolute(sfft)
    
    #
    # Total power is the sum of the (possibly differenced) linear-form
    #   FFT magnitude output
    # I THINK THIS IS THE MOST NUMERICALLY-CORRECT APPROACH.  BUT I
    #   COULD BE WILDLY WRONG.
    #
    if (fast == 0):
        tpower = fftsum(sffts[SKY],exclusions) - fftsum(sffts[REF],exclusions)
    else:
        tpower = scalars[1]-scalars[2]
    
    if (fast == 0):
        #
        # Sky
        #
        skypower = fftsum(sffts[SKY],exclusions)
        if (curr_sky &lt; -50.0):
            curr_sky = skypower
        curr_sky = (alpha*skypower) + (beta*curr_sky)
        
        #
        # Ref
        #
        if (len(ffts) &gt; 1):
            refpower = fftsum(sffts[REF],exclusions)
            if (curr_ref &lt; -50.0):
                curr_ref = refpower
            curr_ref = (alpha*refpower) + (beta*curr_ref)
    else:
        skypower = scalars[1]
        if (curr_sky &lt; -50.0):
            curr_sky = skypower
        curr_sky = (alpha*skypower) + (beta*curr_sky)
        
        refpower = scalars[2]
        if (curr_ref &lt; -50.0):
            curr_ref = refpower
        curr_ref = (alpha*refpower) + (beta*curr_ref)
    
    #
    # Correlation
    #
    if(fast == 0):
        corrpower_real = fftsum(sffts[CORR_REAL],exclusions)
        corrpower_imag = fftsum(sffts[CORR_IMAG],exclusions)
        if (curr_corr_real &lt; -50.0):
            curr_corr_real = corrpower_real
            curr_corr_imag = corrpower_imag
        curr_corr_real = (alpha*corrpower_real) + (beta*curr_corr_real)
        curr_corr_imag = (alpha*corrpower_imag) + (beta*curr_corr_imag)
    else:
        corrpower_real = scalars[0].real
        corrpower_imag = scalars[0].imag
        if (curr_corr_real &lt; -50.0):
            curr_corr_real = corrpower_real
            curr_corr_imag = corrpower_imag
            
        curr_corr_real = (alpha*corrpower_real) + (beta*curr_corr_real)
        curr_corr_imag = (alpha*corrpower_imag) + (beta*curr_corr_imag)
    #
    # Smooth total power estimate with single-pole IIR filter
    #
    #
    if (curr_diff &lt; -50.0):
        curr_diff = tpower

    curr_diff = (alpha*tpower) + (beta*curr_diff)
    
    fft_labels = ["Diff", "Sky", "Ref", "Corr-Real", "Corr-Imag","Corr-Angle"]
    db_ffts = []
    lndx = 0
    corr_ffts = []
    for ufft in [sfft]+sffts:
        #
        # Scale into dB scale for logging
        #
        scaled_fft = numpy.add(ufft,[1.0e-15]*lfft)
        fftype = fft_labels[lndx]
        lndx = lndx+1
        if not ("Corr-" in fftype):
            scaled_fft = numpy.log10(scaled_fft)
            scaled_fft = numpy.multiply (scaled_fft, [10.0]*lfft)
        else:
            corr_ffts.append(scaled_fft)
        db_ffts.append(scaled_fft)

    re = corr_ffts[0]
    im = corr_ffts[1]
    cplx_corr = re +1j*im
    
    db_ffts.append(numpy.angle(cplx_corr))
        
    ltp = time.gmtime()
    sidt = cur_sidereal (longitude)
    
    dprefix = "%04d%02d%02d" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
    
    tfn = expname + "-" + dprefix + "-tp.csv"
  
    #
    # Form the buffer we're going to log to files
    #
    
    #
    # Total (or differential) power first
    #
    tlogbuf = "%02d,%02d,%02d," % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec)
    tlogbuf += "%s," % sidt
    tlogbuf += "%9.4f," % (freq/1.0e6)
    tlogbuf += "%5.2f," % declination
    tlogbuf += "%e,%e,%e,%e,%e\n" % (curr_diff,curr_sky,curr_ref,curr_corr_real,curr_corr_imag)
    
    
    slogbufs = []
    lndx = 0
    for db_fft in db_ffts:
        #
        # Then spectral
        #
        slogbuf = "%02d,%02d,%02d," % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec)
        slogbuf += "%s," % sidt
        slogbuf += "%9.4f," % (freq/1.0e6)
        slogbuf += "%5.2f," % declination
        slogbuf += "%5.2f," % (bw/1.0e6)

        #
        # Spectral data--possibly differenced
        fftype = fft_labels[lndx]
        lndx = lndx + 1
        for i in range(0,len(db_fft)):
            if not ("Corr-" in fftype):
                slogbuf += "%7.3f" % db_fft[i]
            else:
                slogbuf += "%e" % db_fft[i]
                
            if (i &lt; len(sfft)-1):
                slogbuf += ","
        slogbuf += "\n"
        slogbufs.append(slogbuf)
    
    
    if (console != 0):
        if ((count % 5) == 0):
            sys.stdout.write(tlogbuf)
        
    if (local != "" and local != None):
        if (os.path.exists(local)):
            if ((count % 5) == 0):
                tfp = open (os.path.join(local,tfn), "a")
                tfp.write (tlogbuf)
                tfp.close()
            
            if ((count % 45) == 0 and speclog != 0):
                l = 0
                for slogbuf in slogbufs:
                    sfn = expname + "-" + dprefix + "-" + fft_labels[l]
                    sfn += "-spec.csv"
                    sfp = open(os.path.join(local,sfn), "a")
                    sfp.write (slogbuf)
                    sfp.close()
                    swritten = True
                    l += 1
    
    if (remote != "" and remote != None):
        if (os.path.exists(remote)):          
            if ((count % 5) == 0):
                tfp = open (os.path.join(remote,tfn), "a")
                tfp.write (tlogbuf)
                tfp.close()
            
            if ((count % 45) == 0 and speclog != 0):
                l = 0
                for slogbuf in slogbufs:
                    sfn = expname + "-" + dprefix + "-" + fft_labels[l]
                    sfn = "-spec.csv"
                    sfp = open(os.path.join(remote,sfn), "a")
                    sfp.write (slogbuf)
                    sfp.close()
                    swritten = True
                    l += 1
    
    #
    # Handle json file for total power
    #
    ltp = time.gmtime()
    
    lupdate = "%04d%02d%02d-%02d:%02d:%02d" % (ltp.tm_year, ltp.tm_mon,
        ltp.tm_mday, ltp.tm_hour, ltp.tm_min, ltp.tm_sec)
    
    js = {"values" : [curr_diff,curr_sky,curr_ref,curr_corr_real,curr_corr_imag], "expname" : expname, "lmst" : sidt.replace(",", ":"), "dec" : declination,
        "latitude" : latitude, "longitude" : longitude, "updated" : lupdate, "labels" : ["Diff", "Sky", "Ref", "Corr-Real", "Corr-Imag"]}
    jstring = json.dumps(js, indent=4)
    
    try:
        jfp = open(os.path.join(local,"tpower_temp"), "w")
        jfp.write(jstring+"\n")
        jfp.close()
        src = os.path.join(local,"tpower_temp")
        dst = os.path.join(local,"tpower.json")
        os.rename(src,dst)
    except:
        pass
    
    
    #
    # Handle json file for spectral
    #
    
    if ((count % 5) == 0):
        js = {"frequency" : freq, "bandwidth" : bw, "fftsize" : lfft,
            fft_labels[0] : list(db_ffts[0]),
            fft_labels[1] : list(db_ffts[1]),
            fft_labels[2] : list(db_ffts[2]),
            fft_labels[3] : list(db_ffts[3]),
            fft_labels[4] : list(db_ffts[4])}
        jstring = json.dumps(js, indent=4)
        
        try:
            jfp = open(os.path.join(local,"spectral_temp"), "w")
            jfp.write(jstring+"\n")
            jfp.close()
            src = os.path.join(local,"spectral_temp")
            dst = os.path.join(local,"spectral.json")
            os.rename(src, dst)
        except:
            pass
    
    
    
    #
    #
    # Handle old data
    #
    DAY=86400
    WEEK=7
    
    #
    # Roughly once a minute, handle old-data removal
    #
    if ((count % 60) == 0):
        start = int(time.time()) - ((DAY*WEEK)*4)
        end = int(time.time()) - ((DAY*WEEK)*1)
        for tday in range(start,end,DAY):
            ltp = time.gmtime(tday)
            dprefix = "%04d%02d%02d" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
            tfn = expname + "-" + dprefix + "-tp.csv"
            tfn = os.path.join(local, tfn)

            if (os.path.exists(tfn)):
                try:
                    os.remove(tfn)
                except:
                    pass
            
            for lbl in fft_labels:
                sfn = expname + "-" + dprefix + "-" + lbl + "-spec.csv"
                sfn = os.path.join(local,sfn)         
                if (os.path.exists(sfn)):
                    try:
                        os.remove(sfn)
                    except:
                        pass
        
    count += 1
    return True
    
    
def fringe_rate(dec,freq,b):
    C = 299792458.0
    Lambda = C/freq
    fwidth= (math.degrees(Lambda))/b
    fwidth *= (4.0 * 60.0)
    fwidth /= math.cos(math.radians(dec))
    return fwidth

    
def derive_alpha(srate,seconds):
    invterm = 1.0/(srate*seconds)
    alpha = 1.0-math.pow(math.e,-2.0*invterm)
    return alpha
</value></param>
<param><key>comment</key><value>A bunch of helper code--mostly logging</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rstore</value></param>
<param><key>label</key><value>Remote Storage Location</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/nowhere</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>scalar_corr_probe</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>scalar_tp_probe1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>scalar_tp_probe2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>radiometer_helper.derive_alpha(frate,2.5)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0_0</value></param>
<param><key>alpha</key><value>radiometer_helper.derive_alpha(frate,2.5)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0_0_0</value></param>
<param><key>alpha</key><value>radiometer_helper.derive_alpha(frate,2.5)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_1</value></param>
<param><key>alpha</key><value>1.0-math.pow(math.e,-2.0*((1.0/fwidth)/0.4))</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_2</value></param>
<param><key>alpha</key><value>int_alpha</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_2_0</value></param>
<param><key>alpha</key><value>int_alpha</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_3</value></param>
<param><key>alpha</key><value>1.0-math.pow(math.e,-2.0*((1.0/fwidth)/2.0))</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>speclog</value></param>
<param><key>label</key><value>Enable Spectral Logging</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>srate</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>6.0e6</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>raw0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>raw1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>raw0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>raw1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>raw1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>stream_id</key><value>raw0</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_1</source_block_id><sink_block_id>single_pole_iir_filter_xx_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_1_0</source_block_id><sink_block_id>foo</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>fft_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>fft_probe1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1_1</source_block_id><sink_block_id>blocks_complex_to_mag_squared_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_2</source_block_id><sink_block_id>blocks_sub_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_2</source_block_id><sink_block_id>single_pole_iir_filter_xx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_2_0</source_block_id><sink_block_id>scalar_tp_probe1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_2_0_0</source_block_id><sink_block_id>scalar_tp_probe2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_1</source_block_id><sink_block_id>single_pole_iir_filter_xx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_sub_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>fft_corr_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_1</source_block_id><sink_block_id>scalar_corr_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>foo</source_block_id><sink_block_id>blocks_keep_one_in_n_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_2</source_block_id><sink_block_id>blocks_keep_one_in_n_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_2_0</source_block_id><sink_block_id>blocks_keep_one_in_n_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_3</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>blocks_keep_one_in_n_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
